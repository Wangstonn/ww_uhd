options:
  parameters:
    generate_options: qt_gui
    id: GFSK_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Es_Ni
  id: variable
  parameters:
    value: '20'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '-595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_band
  id: variable
  parameters:
    value: 2*200000000/32/336
  states: {}
- name: Pr
  id: variable
  parameters:
    value: '-90'
  states: {}
- name: length
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-F_IF'
    sample_rate: samp_rate
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: length
    max_iter: '4000'
    scale: 1/length
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '16000'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: '" addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: '"addr=192.168.110.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: GFSK
    output_language: python
    title: BLE_Interference_test
  states: {}

blocks:
- name: BLE_fd
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: BLE_sym_length
  id: variable
  parameters:
    value: '.000001'
  states: {}
- name: CH_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ES_Ni
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Pr
  id: variable
  parameters:
    value: '-90'
  states: {}
- name: RX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*BLE_fd/samp_rate
  states: {}
- name: time_s
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '20000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '20000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '20000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/samnolan/OSLA_research/ww_uhd/host/osla-host/interference/gnuradio/log/c16_BLE_20M.bin
    type: short
    vlen: '2'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF-F_Of
    sample_rate: samp_rate
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: time_s*samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0_0_1
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Es_Ni: '-10'
    F_of: '-F_Of'
    Pr: '-90'
    _source_code: |
      """
      Author: Samuel Nolan
      Description:
      Takes in three noise sources on the input and randomly adds them together
      according to a poisson distribution. Internally normalizes inband noise power
      from settings and then multiplies the amplitude according to a log normal distribution.
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block Noise Controller"""

          def __init__(self, sampling_rate = 32000, noise_rate = 1.0, noise_length = 1.0, Es_Ni = 0, Pr = 0, F_of = 0):  # only default arguments here
              """
              Parameters:
              sampling rate (Hz): Needed to calculate length of noise frame and wait frame
              noise_rate (arrivals/second): noise packet rate /s (can overlap up to 3 packets)
              noise length (seconds): length of interference packet (if too large may just overlap constantly)
              Es_Ni(dBm): Desired Es/Ni (Es is hard coded internally)
              Pr(dB): estimate of received power from sending a digital normalized signal 
              F_of (Hz): offset of OSLA from center of BLE noise (-+). Used in in-band normalization calculation.
              analog_gain (dB): To prevent saturation, set analog gain accordingly
              """

              gr.sync_block.__init__(
                  self,
                  name='Noise Controller',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
       
              
              #n_counters[0]: state of interferer
              #n_counters[1]: noise clk(how long its been on)
              #n_counters[2]: gain of interferer (decided on log normal distribution)
              #n_counters[3]: last n_samples of a frame that should include noise
              self.n_counters = np.array([[False,0,1.0,0], [False,0,1.0,0], [False,0,1.0,0]])

              #######################
              #Calculate desired P_I#
              #######################

              #Bandwidth of OSLA signal hardcoded here
              #336 samples/chip
              #32 chips/symbol
              #200000000 samples/second
              #W = 1/R
              Ts = 336*32/200000000
              BW = 2/Ts
              
              #calculate desired interference power to be used in log normal distribution

              Es = -171
              P_I = Es-Es_Ni + 10*np.log10(BW)
              self.mu = P_I - 10*np.log10(noise_rate) - 10*np.log10(noise_length)

              self.Pr = Pr
              
              ########################
              #Normalize In-Band Gain#
              ########################

              #generate normalizer gain from LUT
              file_path = '/home/samnolan/OSLA_research/OSLA/bpsk/interference/MATLAB/BLEwaveform/BLE_PSD.csv'
              try:
                  PSD = np.genfromtxt(file_path,delimiter=',', dtype=np.double)
              except FileNotFoundError:
                  print(f"Error: File not found at {file_path}")


              fbin_width = 100
              #define gain to have normalized in band power
              #With this gain, we will have normalized digital power and receive ~Pr that we measured
              PSD_i_low  = int(np.round((len(PSD)/2) + (F_of/fbin_width) - (BW/fbin_width)/2) + 1)
              PSD_i_high = int(np.round((len(PSD)/2) + (F_of/fbin_width) + (BW/fbin_width)/2))    

              self.G = np.sqrt(1/(fbin_width*np.sum(PSD[PSD_i_low:PSD_i_high,0])))

              self.scale = 0
              
              ##############################
              #set up interferer parameters#
              ##############################
              #phase shift
              self.theta = np.random.uniform(size=len(self.n_counters))*2j*np.pi

              self.sampling_rate = sampling_rate
              self.rate = noise_rate
              self.noise_length = noise_length

              self.noise_frame = np.round((sampling_rate*self.noise_length),0)

              self.arrival_clk = 0
              self.wait_frame = round(((-1/self.rate)*np.log(np.random.uniform())*self.sampling_rate))
              
              self.idx = 0
              self.starved = False
              ########################

              self.DebugPortName = 'Debug'
              self.message_port_register_out(pmt.intern(self.DebugPortName))


          def work(self, input_items, output_items):
              self.arrival_clk = self.arrival_clk + len(output_items[0])
              self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)
              if (self.idx == None) and (self.arrival_clk >= self.wait_frame):
                  self.starved = True
              '''
              #use this to send messages from the debug port
                  PMT_msg = pmt.from_bool(self.state)
                  self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)
              '''

              #run arrival clk and signal when packet should start transmitting
              if ((self.arrival_clk >= self.wait_frame) and not self.starved):
                  self.arrival_clk = self.arrival_clk - self.wait_frame
                  self.wait_frame = round(((-1/self.rate)*np.log(np.random.uniform())*self.sampling_rate))
                  #Mark Interferer to start
                  self.n_counters[self.idx][0] = True
                  #generate gain value from parameters
                  P = np.random.normal(loc=self.mu, scale=self.scale)
                  self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-self.Pr)/10))
                  #generate new phase offset
                  self.theta[self.idx] = np.random.uniform()*2j*np.pi
                  self.n_counters[self.idx][3] = self.arrival_clk
                  
                  
                  #if next wait_frame occurs in same window
                  self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)
                  if ((self.arrival_clk >= self.wait_frame) and (self.idx != None)):
                      self.arrival_clk = self.arrival_clk - self.wait_frame
                      self.wait_frame = round(((-1/self.rate)*np.log(np.random.uniform())*self.sampling_rate))
                      #Mark Interferer to start
                      self.n_counters[self.idx][0] = True
                      #generate gain value from parameters
                      P = np.random.normal(loc=self.mu, scale=self.scale)
                      self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-self.Pr)/10))
                      #generate new phase offset
                      self.theta[self.idx] = np.random.uniform()*2j*np.pi
                      self.n_counters[self.idx][3] = self.arrival_clk

                      #if all three interferers occur in the same window
                      self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)
                      if ((self.arrival_clk >= self.wait_frame) and (self.idx != None)):
                          self.arrival_clk = self.arrival_clk - self.wait_frame
                          self.wait_frame = round(((-1/self.rate)*np.log(np.random.uniform())*self.sampling_rate))
                          #Mark Interferer to start
                          self.n_counters[self.idx][0] = True
                          #generate gain value from parameters
                          P = np.random.normal(loc=self.mu, scale=self.scale)
                          self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-self.Pr)/10))
                          #generate new phase offset
                          self.theta[self.idx] = np.random.uniform()*2j*np.pi
                          self.n_counters[self.idx][3] = self.arrival_clk
                  
                  #PMT_msg = pmt.to_pmt(self.wait_frame)
                  #self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)

              #If we are starved we want to start noise immediately and also reset the arrival clock to prevent error buildup
              if ((self.idx != None) and self.starved):
                  self.arrival_clk = len(output_items[0])
                  self.wait_frame = round(((-1/self.rate)*np.log(np.random.uniform())*self.sampling_rate))
                  #Mark Interferer to start
                  self.n_counters[self.idx][0] = True
                  #generate gain value from parameters
                  P = np.random.normal(loc=self.mu, scale=self.scale)
                  self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-self.Pr)/10))
                  #generate new phase offset
                  self.theta[self.idx] = np.random.uniform()*2j*np.pi
                  self.starved = False

                  
              output_items[0][:] = 0
              for i in range(len(self.n_counters)):
                  if(self.n_counters[i][0]):

                      if(self.n_counters[i][3] != 0):
                          self.n_counters[i][1] = self.n_counters[i][1] + self.n_counters[i][3]
                          output_items[0][-int(self.n_counters[i][3]):] = output_items[0][-int(self.n_counters[i][3]):] + self.n_counters[i][2]*input_items[i][-int(self.n_counters[i][3]):]*np.exp(self.theta[i])
                          self.n_counters[i][3] = 0
                      else:
                          self.n_counters[i][1] = self.n_counters[i][1] + len(output_items[0])
                          
                          if(self.n_counters[i][1] > self.noise_frame):
                              end_n_elem = len(output_items[0]) - (self.n_counters[i][1] - self.noise_frame)
                              output_items[0][:int(end_n_elem)] = output_items[0][:int(end_n_elem)] + self.n_counters[i][2]*input_items[i][:int(end_n_elem)]*np.exp(self.theta[i])
                              self.n_counters[i][0] = False
                              self.n_counters[i][1] = 0
                          else:
                              output_items[0][:] = output_items[0][:] + self.n_counters[i][2]*input_items[i]*np.exp(self.theta[i])

                      

              if(abs(output_items[0][0]) > 1):
                  PMT_msg = pmt.string_to_symbol("Warning: USRP is saturated, please edit analog gain in flowgraph")
                  self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)
              #    return -1
              return len(output_items[0][:])
    noise_length: '.002'
    noise_rate: '200'
    sampling_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: TX_ID
    gain0: CH_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: RX_ID
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_gfsk_mod_0_0_0, '0']
- [analog_random_source_x_0_0, '0', digital_gfsk_mod_0_0_0_0, '0']
- [analog_random_source_x_0_1, '0', digital_gfsk_mod_0_0_0_1, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0_0_0, '0', epy_block_0, '0']
- [digital_gfsk_mod_0_0_0_0, '0', epy_block_0, '1']
- [digital_gfsk_mod_0_0_0_1, '0', epy_block_0, '2']
- [epy_block_0, '0', blocks_freqshift_cc_0, '0']
- [epy_block_0, Debug, blocks_message_debug_0, print]
- [uhd_usrp_source_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1

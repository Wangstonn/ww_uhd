options:
  parameters:
    generate_options: no_gui
    id: BLE_Interference
    output_language: python
    run_options: run
    title: BLE_Interference
  states: {}

blocks:
- name: BLE_fd
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: BLE_sym_length
  id: variable
  parameters:
    value: '.000001'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*BLE_fd/samp_rate
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: ch_gain
  id: parameter
  parameters:
    label: Analog Antenna Gain (dB)
    type: eng_float
    value: '20'
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0_0_0_1
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    F_of: F_Of
    _source_code: "\"\"\"\nAuthor: Samuel Nolan\nDescription:\nTakes in three noise sources on the input and randomly adds them together\naccording to a poisson distribution. Internally normalizes inband noise power\nfrom settings and then multiplies the amplitude according to a log normal distribution.\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport threading  \n\n\nimport os\nfrom pathlib import Path\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block Noise Controller\"\"\"\n\n    def __init__(self, sampling_rate = 32000, noise_intensity = 1.0, noise_length = 1.0, target_Pi = 0, estimated_Pr = 0, F_of = 0):  # only default arguments here\n        \"\"\"\n        Parameters:\n        sampling rate (Hz): Needed to calculate length of noise frame and wait frame\n        noise_intensity (arrivals/second): noise packet rate /s (can overlap up to 3 packets)\n        noise length (seconds): length of interference packet (if too large may just overlap constantly)\n        Es_Ni(dBm): Desired Es/Ni (Es is hard coded internally)\n        Pr(dB): estimate of received power from sending a digital normalized signal \n        F_of (Hz): offset of OSLA from center of BLE noise (-+). Used in in-band normalization calculation.\n        analog_gain (dB): To prevent saturation, set analog gain accordingly\n        \"\"\"\n        self._lock = threading.Lock() \n\n        gr.sync_block.__init__(\n            self,\n            name='Noise Controller',   # will show up in GRC\n            in_sig=[np.complex64,np.complex64,np.complex64],\n            out_sig=[np.complex64]\n        )\n \n        \n        #n_counters[0]: state of interferer\n        #n_counters[1]: noise clk(how long its been on)\n        #n_counters[2]: gain of interferer (decided on log normal distribution)\n        #n_counters[3]: last n_samples of a frame that should include noise\n        self.n_counters = np.array([[False,0,1.0,0], [False,0,1.0,0], [False,0,1.0,0]])\n\n        #######################\n        #Calculate desired P_I#\n        #######################\n\n        #Bandwidth of OSLA signal hardcoded here\n        #336 samples/chip\n        #32 chips/symbol\n        #200000000 samples/second\n        #W = 1/R\n        Ts = 336*32/200000000\n        self.BW = 2/Ts\n        \n        #calculate desired interference power to be used in log normal distribution\n        self.lognormVar = 10\n        #Es = -171\n        #N_I = Es-Es_Ni\n        #self.mu = N_I - 10*np.log10(noise_rate*noise_length*np.exp((self.lognormVar*(np.log(10))**2)/200)) + 10*np.log10(self.BW)\n        # set by socket code\n        # self.mu = Pi - 10*np.log10(noise_rate*noise_length*np.exp((self.lognormVar*(np.log(10))**2)/200))\n\n        # self.Pr = Pr\n        ########################\n        #Normalize In-Band Gain#\n        ########################\n\n        #generate normalizer gain from LUT\n        #run locally from grc_graphs folder\n        # Hardcoded full path to PSD file (use forward slashes for safety)\n        #PSD_path =  os.path.join(os.path.dirname(__file__), \"../../matlab/psd/ble_psd.csv\") \n        PSD_path = 'C:/Users/wangston/My Drive/OSLA/bpsk/ww_uhd/host/osla-host/interference/matlab/psd/ble_psd.csv'\n        print(f\"[NoiseController] Loading hardcoded PSD file: {PSD_path}\")\n\n        PSD = None  # prevent undefined var\n\n        try:\n            PSD_file = Path(PSD_path)\n            if not PSD_file.is_file():\n                raise FileNotFoundError(f\"File does not exist: {PSD_file}\")\n            \n            PSD = np.genfromtxt(PSD_file, delimiter=',', dtype=np.double)\n            if PSD.ndim < 2 or PSD.shape[1] < 1:\n                raise ValueError(\"PSD file must be at least 2D with one column.\")\n\n            print(f\"[NoiseController] PSD loaded with shape {PSD.shape}\")\n\n        except Exception as e:\n            raise RuntimeError(f\"[NoiseController ERROR] Failed to load PSD: {e}\")\n\n\n        df = 100\n        fs_psd = 10000000\n        #define gain to have normalized in band power\n        #With this gain, we will have normalized digital power and receive ~Pr that we measured\n        PSD_i_low  = int(np.round((len(PSD)/2) + (F_of/df) - (self.BW/df)/2) - 1)\n        PSD_i_high = int(np.round((len(PSD)/2) + (F_of/df) + (self.BW/df)/2))    \n\n        self.G = np.sqrt(1/(df*np.sum(PSD[PSD_i_low:PSD_i_high,0]*fs_psd)))\n        \n        ##############################\n        #set up interferer parameters#\n        ##############################\n        #phase shift\n        self.theta = np.random.uniform(size=len(self.n_counters))*2j*np.pi\n\n        self.sampling_rate = sampling_rate\n        self.pkt_intensity = noise_intensity\n        self.pkt_len = noise_length\n\n        self.noise_frame = np.round((sampling_rate*self.pkt_len),0)\n\n        self.update_params(False, target_Pi, estimated_Pr)\n\n        self.arrival_clk = 0\n        self.wait_frame = round(((-1/self.pkt_intensity)*np.log(np.random.uniform())*self.sampling_rate))\n        \n        self.idx = 0\n        self.full = False\n        ########################\n\n        self.DebugPortName = 'Debug'\n        self.message_port_register_out(pmt.intern(self.DebugPortName))\n    \n    #Update packet generation parameters using the input parameters    \n    def update_params(self, enabled, target_Pi, estimated_Pr):\n        with self._lock:\n            self.enabled = enabled\n            mu_linear = 1/(self.pkt_intensity*self.pkt_len)*np.exp((self.lognormVar*(np.log(10))**2)/200)\n            self.mu = target_Pi + 10*np.log10(mu_linear)\n            self.Pr = estimated_Pr\n\n    def work(self, input_items, output_items):\n        with self._lock:\n            enabled = self.enabled\n            mu = self.mu\n            Pr = self.Pr\n        # use 'enabled', `mu` and `Pr` instead of self.mu/self.Pr in the rest of the function\n        \n        #gate activity of block using enabled flag\n        if not enabled:\n            # Work output the number of output items produced. Return 0 to pause downstream blocks.\n            return 0\n\n        self.arrival_clk = self.arrival_clk + len(output_items[0])\n        self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)\n        if (self.idx == None) and (self.arrival_clk >= self.wait_frame):\n            self.full = True\n        '''\n        #use this to send messages from the debug port\n            PMT_msg = pmt.from_bool(self.state)\n            self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)\n        '''\n\n        #run arrival clk and signal when packet should start transmitting\n        if ((self.arrival_clk >= self.wait_frame) and not self.full):\n            self.arrival_clk = self.arrival_clk - self.wait_frame\n            self.wait_frame = round(((-1/self.pkt_intensity)*np.log(np.random.uniform())*self.sampling_rate))\n            #Mark Interferer to start\n            self.n_counters[self.idx][0] = True\n            #generate gain value from parameters\n            P = np.random.normal(loc=mu, scale=self.lognormVar)\n            self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-Pr)/10))\n            #generate new phase offset\n            self.theta[self.idx] = np.random.uniform()*2j*np.pi\n            self.n_counters[self.idx][3] = self.arrival_clk\n            \n            \n            #if next wait_frame occurs in same window\n            self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)\n            if ((self.arrival_clk >= self.wait_frame) and (self.idx != None)):\n                self.arrival_clk = self.arrival_clk - self.wait_frame\n                self.wait_frame = round(((-1/self.pkt_intensity)*np.log(np.random.uniform())*self.sampling_rate))\n                #Mark Interferer to start\n                self.n_counters[self.idx][0] = True\n                #generate gain value from parameters\n                P = np.random.normal(loc=mu, scale=self.lognormVar)\n                self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-Pr)/10))\n                #generate new phase offset\n                self.theta[self.idx] = np.random.uniform()*2j*np.pi\n                self.n_counters[self.idx][3] = self.arrival_clk\n\n                #if all three interferers occur in the same window\n                self.idx = next((i for i,j in enumerate(self.n_counters) if not j[0]),None)\n                if ((self.arrival_clk >= self.wait_frame) and (self.idx != None)):\n                    self.arrival_clk = self.arrival_clk - self.wait_frame\n                    self.wait_frame = round(((-1/self.pkt_intensity)*np.log(np.random.uniform())*self.sampling_rate))\n                    #Mark Interferer to start\n                    self.n_counters[self.idx][0] = True\n                    #generate gain value from parameters\n                    P = np.random.normal(loc=mu, scale=self.lognormVar)\n                    self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-Pr)/10))\n                    #generate new phase offset\n                    self.theta[self.idx] = np.random.uniform()*2j*np.pi\n                    self.n_counters[self.idx][3] = self.arrival_clk\n            \n            #PMT_msg = pmt.to_pmt(self.wait_frame)\n            #self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)\n\n        #If we are full we want to start noise immediately and also reset the arrival clock to prevent error buildup\n        if ((self.idx != None) and self.full):\n            self.arrival_clk = len(output_items[0])\n            self.wait_frame = round(((-1/self.pkt_intensity)*np.log(np.random.uniform())*self.sampling_rate))\n            #Mark Interferer to start\n            self.n_counters[self.idx][0] = True\n            #generate gain value from parameters\n            P = np.random.normal(loc=mu, scale=self.lognormVar)\n            self.n_counters[self.idx][2] = self.G*np.sqrt(10**((P-Pr)/10))\n            #generate new phase offset\n            self.theta[self.idx] = np.random.uniform()*2j*np.pi\n            self.full = False\n\n            \n        output_items[0][:] = 0\n        for i in range(len(self.n_counters)):\n            if(self.n_counters[i][0]):\n\n                if(self.n_counters[i][3] != 0):\n                    self.n_counters[i][1] = self.n_counters[i][1] + self.n_counters[i][3]\n                    output_items[0][-int(self.n_counters[i][3]):] = output_items[0][-int(self.n_counters[i][3]):] + self.n_counters[i][2]*input_items[i][-int(self.n_counters[i][3]):]*np.exp(self.theta[i])\n                    self.n_counters[i][3] = 0\n                else:\n                    self.n_counters[i][1] = self.n_counters[i][1] + len(output_items[0])\n                    \n                    if(self.n_counters[i][1] > self.noise_frame):\n                        end_n_elem = len(output_items[0]) - (self.n_counters[i][1] - self.noise_frame)\n                        output_items[0][:int(end_n_elem)] = output_items[0][:int(end_n_elem)] + self.n_counters[i][2]*input_items[i][:int(end_n_elem)]*np.exp(self.theta[i])\n                        self.n_counters[i][0] = False\n                        self.n_counters[i][1] = 0\n                    else:\n                        output_items[0][:] = output_items[0][:] + self.n_counters[i][2]*input_items[i]*np.exp(self.theta[i])\n\n                \n\n        if(abs(output_items[0][0]) > 1):\n            PMT_msg = pmt.string_to_symbol(\"Warning: USRP is saturated, please edit analog gain in flowgraph\")\n            self.message_port_pub(pmt.intern(self.DebugPortName), PMT_msg)\n            #return -1\n        return len(output_items[0][:])\n\n"
    estimated_Pr: estPr
    noise_intensity: '200'
    noise_length: '.002'
    sampling_rate: samp_rate
    target_Pi: targPi
  states: {}
- name: estPr
  id: parameter
  parameters:
    label: estimated_Pr
    type: eng_float
    value: '-86.98'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: targPi
  id: parameter
  parameters:
    label: target_Pi
    type: eng_float
    value: '-125'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Analog Antenna TX Frequency
    type: eng_float
    value: 2.4e9
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: tx_freq
    clock_source0: external
    dev_addr: TX_ID
    gain0: ch_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: use_Socket
  id: parameter
  parameters:
    label: 1 = use socket. 0 = use pr and pi set by input
    type: intx
    value: '1'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_gfsk_mod_0_0_0, '0']
- [analog_random_source_x_0_0, '0', digital_gfsk_mod_0_0_0_0, '0']
- [analog_random_source_x_0_1, '0', digital_gfsk_mod_0_0_0_1, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_0_0_0, '0', epy_block_0, '0']
- [digital_gfsk_mod_0_0_0_0, '0', epy_block_0, '1']
- [digital_gfsk_mod_0_0_0_1, '0', epy_block_0, '2']
- [epy_block_0, '0', blocks_freqshift_cc_0, '0']
- [epy_block_0, Debug, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0

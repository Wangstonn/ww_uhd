options:
  parameters:
    author: Samuel Nolan
    generate_options: qt_gui
    id: Single_Tone_Estimator
    output_language: python
    title: Single_Tone_Estimator
  states: {}

blocks:
- name: BLE_fd
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: BLE_sym_length
  id: variable
  parameters:
    value: '.000001'
  states: {}
- name: CH_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_band
  id: variable
  parameters:
    value: 2*200000000/(336*32)
  states: {}
- name: Pr
  id: variable
  parameters:
    value: '-90.33'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*BLE_fd/samp_rate
  states: {}
- name: time_s
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '20000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF
    sample_rate: samp_rate
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    F_band: F_band
    F_of: '0'
    P: '-135'
    Pr: Pr
    _source_code: |
      """
      Embedded Python Blocks:

      This block is a stand-alone block that takes in 1 BLE interferer to test 
      normalizing in band noise capabilities

      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Normalizer"""

          def __init__(self, sampling_rate = 32000, Pr=0, P=0, F_band = 30000, F_of = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sampling_rate = sampling_rate
              self.F_of = F_of
              BW = F_band
              
              self.Pr = Pr

              #generate normalizer gain from LUT
              file_path = '/n/deer/z/samnolan/BLE_PSD.csv'

              try:
                  PSD = np.genfromtxt(file_path,delimiter=',', dtype=np.double)
              except FileNotFoundError:
                  print(f"Error: File not found at {file_path}")

              fbin_width = 100
              #define gain to have normalized in band power
              #With this gain, we will have normalized digital power and receive ~Pr that we measured
              PSD_i_low  = int(np.round((len(PSD)/2) + (F_of/fbin_width) - (BW/fbin_width)/2) + 1)
              PSD_i_high = int(np.round((len(PSD)/2) + (F_of/fbin_width) + (BW/fbin_width)/2))    

              self.G = np.sqrt(1/(fbin_width*np.sum(PSD[PSD_i_low:PSD_i_high,0])))*np.sqrt(10**((P-self.Pr)/10))

          def work(self, input_items, output_items):
              output_items[0][:] = self.G*input_items[0]

              return len(output_items[0])
    sampling_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: TX_ID
    gain0: CH_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_gfsk_mod_0_0_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_0_0_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1

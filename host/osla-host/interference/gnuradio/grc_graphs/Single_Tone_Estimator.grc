options:
  parameters:
    author: Samuel Nolan
    generate_options: no_gui
    id: Single_Tone_Estimator
    output_language: python
    run_options: run
    title: Single_Tone_Estimator
  states: {}

blocks:
- name: CH_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF
    sample_rate: samp_rate
  states: {}
- name: ch_gain
  id: parameter
  parameters:
    label: Analog Antenna Gain (dB)
    type: eng_float
    value: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Analog Antenna TX Frequency
    type: eng_float
    value: 2.4e9
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Analog Front end Tx frequency
    type: eng_float
    value: 2.2e9
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: tx_freq
    clock_source0: external
    dev_addr: TX_ID
    gain0: CH_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1

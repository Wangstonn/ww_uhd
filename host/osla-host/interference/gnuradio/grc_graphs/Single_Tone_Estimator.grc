options:
  parameters:
    author: Samuel Nolan
    generate_options: qt_gui
    id: Single_Tone_Estimator
    output_language: python
    title: Single_Tone_Estimator
  states: {}

blocks:
- name: CH_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_IF
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: RX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: time_s
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/samnolan/OSLA_research/ww_uhd/host/osla-host/interference/gnuradio/log/c16_SingleTone_20M.bin
    type: short
    vlen: '2'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_IF
    sample_rate: samp_rate
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: time_s*samp_rate
    type: short
    vlen: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: TX_ID
    gain0: CH_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: RX_ID
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1

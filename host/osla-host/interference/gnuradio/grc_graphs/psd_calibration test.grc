options:
  parameters:
    author: Winston Wang
    description: Transmits constant interference for a target noise level. Used to verify the psd logic is correct.
    generate_options: no_gui
    id: psd_calibration_test
    output_language: python
    title: psd_calibration_test
  states: {}

blocks:
- name: BLE_fd
  id: variable
  parameters:
    comment: BLE frequency deviation
    value: '250000'
  states: {}
- name: BLE_sym_length
  id: variable
  parameters:
    value: '.000001'
  states: {}
- name: F_If
  id: variable
  parameters:
    value: '595238'
  states: {}
- name: F_Of
  id: variable
  parameters:
    value: '0'
  states: {}
- name: TX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: fs
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*BLE_fd/fs
  states: {}
- name: P_received
  id: parameter
  parameters:
    label: 'P_received (float): Measured received power of unit power sinusoid at receiver in dBm.'
    type: eng_float
    value: '  -72.51'
  states: {}
- name: P_target
  id: parameter
  parameters:
    label: '        P_target (float): Target power level for normalization in dBm.'
    type: eng_float
    value: '-100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: F_If
    sample_rate: fs
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: ch_gain
  id: parameter
  parameters:
    label: Analog Antenna Gain (dB)
    type: eng_float
    value: '0'
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*fs)
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    P_received: P_received
    P_target: P_target
    _source_code: |
      """
      Embedded Python Blocks:

      This block is a stand-alone block that takes in 1 BLE interferer to test 
      normalizing in band noise capabilities

      """

      import numpy as np
      from gnuradio import gr

      import os # To load PSD file
      from pathlib import Path

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          GNU Radio block to normalize an input complex signal to a target power level
          based on a known power spectral density (PSD) profile.

          This block computes a gain factor that scales the input signal such that
          its power matches a desired target power (in dBm), assuming the received power
          is known. The gain is computed using the in-band power extracted from a PSD
          file generated (e.g., via MATLAB's pwelch). The PSD is used to model the spectral
          shape of additive noise or interference. Currently the pwelch bin size, df, is set to 100 Hz.

          Parameters:
              fs (float): Sampling frequency in Hz. Used to scale PSD from digital to analog units.
              P_received (float): Measured received power of unit power sinusoid at receiver in dBm.
              P_target (float): Target power level for normalization in dBm.
              bw (float): Bandwidth over which to compute power, in Hz.
              fc (float): Center frequency of interest within the PSD, in Hz.
              selector (int): Selects which PSD file to load.
                              0 = AWGN PSD (awgn_psd.csv)
                              1 = BLE PSD (ble_psd.csv)

          Raises:
              RuntimeError: If PSD file cannot be found or loaded properly.
              ValueError: If selector is not 0 or 1.
          """
          def __init__(self, fs=10e6, P_received=-44.64, P_target=-126.84, bw=18.5e3, fc=595e3, selector=0):
              """arguments to this function show up as parameters in GRC"""
              
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # Persistent parameters needed during work()
              self.fs = fs
              self.P_received = P_received
              self.P_target = P_target

              #generate normalizer gain from LUT
              match selector:
                  case 0:
                      base_dir = os.path.abspath(os.path.join(os.getcwd(), "..", ".."))
                      PSD_path = os.path.join(base_dir, "matlab", "psd", "awgn_psd.csv")
                      #PSD_path = os.path.join(os.path.dirname(__file__), "../../matlab/psd/awgn_psd.csv") #'C:/Users/wangston/My Drive/OSLA/bpsk/ww_uhd/host/osla-host/interference/matlab/BLEwaveform/gaussian_PSD.csv'
                      #PSD_path = 'C:/Users/wangston/My Drive/OSLA/bpsk/ww_uhd/host/osla-host/interference/matlab/psd/awgn_psd.csv'
                  case 1:
                      base_dir = os.path.abspath(os.path.join(os.getcwd(), "..", ".."))
                      PSD_path = os.path.join(base_dir, "matlab", "psd", "ble_psd.csv")                
      #PSD_path = os.path.join(os.getcwd(), "matlab", "psd", "ble_psd.csv")
                       #PSD_path = os.path.join(os.path.dirname(__file__), "../../matlab/psd/ble_psd.csv") #'C:/Users/wangston/My Drive/OSLA/bpsk/ww_uhd/host/osla-host/interference/matlab/BLEwaveform/gaussian_PSD.csv'
                      #PSD_path = 'C:/Users/wangston/My Drive/OSLA/bpsk/ww_uhd/host/osla-host/interference/matlab/psd/ble_psd.csv'
                  case _:
                      raise ValueError("Selector must be 0 or 1, got {}".format(selector))

              PSD = None  # prevent undefined var

              try:
                  PSD_file = Path(PSD_path)
                  if not PSD_file.is_file():
                      raise FileNotFoundError(f"File does not exist: {PSD_file}")
                  
                  PSD = np.genfromtxt(PSD_file, delimiter=',', dtype=np.double)
                  if PSD.ndim < 2 or PSD.shape[1] < 1:
                      raise ValueError("PSD file must be at least 2D with one column.")

                  print(f"[NoiseController] PSD loaded with shape {PSD.shape}")

              except Exception as e:
                  raise RuntimeError(f"[NoiseController ERROR] Failed to load PSD: {e}")

              # Scale signal to match the target received power
              df = 100
              #fs_psd = 10000000
              PSD_i_low  = int(np.round((len(PSD)/2) + (fc/df) - (bw/df)/2) - 1)
              PSD_i_high = int(np.round((len(PSD)/2) + (fc/df) + (bw/df)/2))    

              # in band power = sum(PSD)*df*fs
              P_band = df*np.sum(PSD[PSD_i_low:PSD_i_high,0])#*fs)
              self.G = np.sqrt(1/(P_band))
              print("Gain: ", self.G*10**((self.P_target-self.P_received)/20))

          def work(self, input_items, output_items):
              output_items[0][:] = self.G*10**((self.P_target-self.P_received)/20)*input_items[0]
              return len(output_items[0])
    bw: 200e6/(336*32)*2
    fc: F_Of
    fs: fs
    selector: selector
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: selector
  id: parameter
  parameters:
    label: 'selector (int): Selects which PSD file to load. 0 = AWGN PSD, 1 = BLE PSD'
    type: intx
    value: '0'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Analog Frontend Tx frequency
    type: eng_float
    value: 2.2e9
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: tx_freq
    clock_source0: internal
    dev_addr: TX_ID
    gain0: ch_gain
    samp_rate: fs
    sync: none
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_selector_0, '0']
- [analog_random_source_x_0, '0', digital_gfsk_mod_0_0_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_selector_0, '0', epy_block_0, '0']
- [digital_gfsk_mod_0_0_0, '0', blocks_selector_0, '1']
- [epy_block_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

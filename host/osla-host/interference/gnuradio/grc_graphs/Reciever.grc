options:
  parameters:
    generate_options: qt_gui
    id: Reciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: time_s
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/samnolan/c16_BLE_constAmp_EsNi0dB_10M.bin
    type: short
    vlen: '2'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: time_s*samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: short
    vlen: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '160000000'
    center_freq0: '2400000000'
    clock_source0: external
    dev_addr: RX_ID
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: no_gui
    id: sample_capture_no_gui
    output_language: python
    title: sample capture
  states: {}

blocks:
- name: RX_ID
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/samnolan/c16_noise_10M.bin
    type: short
    vlen: '2'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(capture_t*samp_rate)
    type: short
    vlen: '2'
  states: {}
- name: capture_t
  id: parameter
  parameters:
    label: capture time duration
    type: eng_float
    value: '4'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Analog Front end Tx frequency
    type: eng_float
    value: 2.2e9
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: '160000000'
    center_freq0: tx_freq
    clock_source0: external
    dev_addr: RX_ID
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

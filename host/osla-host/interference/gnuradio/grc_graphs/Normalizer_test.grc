options:
  parameters:
    generate_options: qt_gui
    id: Normalizer_test
    output_language: python
    title: Normalizer_test
  states: {}

blocks:
- name: BLE_sym_length
  id: variable
  parameters:
    value: '.000001'
  states: {}
- name: F_band
  id: variable
  parameters:
    value: 2*200000000/336/32
  states: {}
- name: F_band_0
  id: variable
  parameters:
    value: 2*200000000/336/32
  states: {}
- name: F_if
  id: variable
  parameters:
    value: '0'
  states: {}
- name: F_if_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fd
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*fd/samp_rate
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: F_if + F_band/2
    interp: '1'
    low_cutoff_freq: F_if - F_band/2
    samp_rate: samp_rate
    type: interp_fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000000'
    max_iter: '4000'
    scale: 1/1000000
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    do_unpack: 'False'
    samples_per_symbol: round(BLE_sym_length*samp_rate)
    sensitivity: sensitivity
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    F_band: F_band
    F_of: F_if
    _source_code: |
      """
      Embedded Python Blocks:

      This block is a stand-alone block that takes in 1 BLE interferer to test 
      normalizing in band noise capabilities

      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Normalizer"""

          def __init__(self, sampling_rate = 32000, F_band = 30000, F_of = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sampling_rate = sampling_rate
              self.F_of = F_of
              BW = F_band

              #generate normalizer gain from LUT
              file_path = '/home/samnolan/OSLA_research/OSLA/bpsk/interference/MATLAB/BLEwaveform/BLE_PSD.csv'

              try:
                  PSD = np.genfromtxt(file_path,delimiter=',', dtype=np.double)
              except FileNotFoundError:
                  print(f"Error: File not found at {file_path}")

              fbin_width = 100

              #define gain to have normalized in band power
              #With this gain, we will have normalized digital power and receive ~Pr that we measured
              PSD_i_low  = int(np.round((len(PSD)//2) - 1 + (F_of//fbin_width) - ((BW/fbin_width)//2)-25))
              PSD_i_high = int(np.round((len(PSD)//2) - 1 + (F_of//fbin_width) + ((BW/fbin_width)//2)+25))    

              self.G = np.sqrt(1/(fbin_width*np.sum(PSD[PSD_i_low:PSD_i_high,0])))

          def work(self, input_items, output_items):
              output_items[0][:] = self.G*input_items[0]

              return len(output_items[0])
    sampling_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_gfsk_mod_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', band_pass_filter_0, '0']
- [digital_gfsk_mod_0_0_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
